# Keil uVision project SimpleOscillograph For STM32.uvprojx, settings and files
target SimpleOscillograph (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SimpleOscillograph For STM32 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\USB\lib;..\USB\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c adc.c exti.c led.c Time.c Queue.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_adc.c misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group USB
    ../USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group USB/Lib
    ../USB/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
software components: CMSIS:CORE 4.3.0
